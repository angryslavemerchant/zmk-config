## boards/shields/BinkusScroll/Kconfig.defconfig
```kconfig
if SHIELD_BinkusScroll

config ZMK_KEYBOARD_NAME
    default "BinkusScroll"

endif
```
